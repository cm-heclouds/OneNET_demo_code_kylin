# Keil uVision project onenetdemo.uvproj, settings and files
target OneNET_Demo_ESP8266_MQTT (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: onenetdemo
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Hal;..\Utils;..\Devices;..\Protocol\mqtt;..\Network\esp8266;..\object;..\Project;..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\CMSIS\startup\arm;..\EDP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c
  group HAL
    ../Hal/: usart1.c usart1.h usart2.c usart2.h
  group PROTOCOL
    ../Protocol/mqtt/: config.h mqtt.c mqtt.h mqtt_buffer.c mqtt_buffer.h mqtt_loop.c mqtt_loop.h
  group UTILS
    ../Utils/: utils.c utils.h
  group NETWORK
    ../Network/esp8266/: esp8266.c esp8266.h
  group DEVICES
    ../Devices/: hal_i2c.c hal_i2c.h sht20.c sht20.h
