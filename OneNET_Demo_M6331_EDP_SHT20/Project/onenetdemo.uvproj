# Keil uVision project onenetdemo.uvproj, settings and files
target OneNET_Demo_M6331_EDP_SHT20 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: onenetdemo
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Hal;..\Utils;..\Protocol\edp;..\Devices;..\Network\m6331;..\Network\esp8266;..\object;..\Project;..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\CMSIS\startup\arm;..\EDP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c stm32f10x_it.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DEVICES
    ../Devices/: hal_i2c.c hal_i2c.h sht20.c sht20.h
  group HAL
    ../Hal/: usart1.c usart1.h usart2.c usart2.h gpio.c gpio.h
  group PROTOCOL
    ../Protocol/edp/: EdpDemo.c EdpKit.c EdpKit.h EdpDemo.h
  group UTILS
    ../Utils/: cJSON.c cJSON.h utils.c utils.h
  group NETWORK
    ../Network/esp8266/: esp8266.c esp8266.h
    ../Network/m6331/: M6331.c m6331.h
